# Keil uVision project uart.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Sources;.\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Libraries\CMSIS\Include;.\Libraries\STM32F30x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Library
    ./Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f303xe.s
    ./Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_dma.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_usart.c stm32f30x_tim.c stm32f30x_exti.c stm32f30x_syscfg.c
  group User
    ./Sources/: main.c stm32f30x_it.c nucleo_led.c nucleo_uart.c
